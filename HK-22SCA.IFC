Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-22SCA.IFC
Time: 2022-01-05T02:35:33
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2200三合一內盒 (2)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
2200三合一內盒 | 0
2200三合一內盒 | Steel

# IfcBuildingElementProxy: 2200三合一固定片 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2200三合一外殼B
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 2200三合一外殼固定片D (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Hitachi電源端子盤
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 伸長10
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 出風口柵門3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 垃圾筒
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 垃圾箱門B
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 紙巾箱B
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 除料-伸長9
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 馬達固定螺絲M5×10
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
